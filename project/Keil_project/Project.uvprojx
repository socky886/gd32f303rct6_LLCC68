# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (ARM-ADS)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group LLCC68
    ../../LLCC68/src/radio/sx126x/: radio.c sx126x.c
    ../../LLCC68/board/: gd32f303rct6_board.c sx1262-board.c
target GD32F30X_XD (ARM-ADS)
  device: GD32F303RK GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF)IROM(0x08000000-0x082FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
target GD32F30X_HD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000-0x2000FFFF)IROM(0x08000000-0x0807FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\;..\..\LLCC68\src\radio;..\..\LLCC68\src\radio\sx126x;..\..\LLCC68\board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
